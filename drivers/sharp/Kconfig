## drivers/sharp/Kconfig
```kconfig
#
# SHARP configuration
#

menu "SHARP Device Drivers"

source "drivers/sharp/shboot/Kconfig"
source "drivers/sharp/shgrip/Kconfig"

endmenu
```
